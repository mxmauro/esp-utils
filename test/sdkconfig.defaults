## test/sdkconfig.defaults
```kconfig
CONFIG_PARTITION_TABLE_SINGLE_APP_LARGE=y

CONFIG_PM_SLEEP_FUNC_IN_IRAM=y
CONFIG_ESP_SYSTEM_EVENT_TASK_STACK_SIZE=4096
```
